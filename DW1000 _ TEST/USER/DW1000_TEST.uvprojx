# Keil uVision project DW1000_TEST.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DW1000_TEST
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --gnu
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\LINK_OUT\HAL_24C02;..\LINK_OUT\HAL_LTDC;..\HAL_LIB\Inc;..\CORE;..\LINK_OUT\HAL_SDRAM;..\LINK_OUT\KEY;..\LINK_OUT\LCD;..\LINK_OUT\LED;..\LINK_OUT\TIM;..\LINK_OUT\FONT;..\LINK_OUT\HAL_RGB_FONT;..\DWM1000_Con;..\LINK_OUT\USART;..\DWM1000_Con
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group LINK_OUT
    ../LINK_OUT/KEY/: KEY.c
    ../LINK_OUT/LED/: LED.c
    ../LINK_OUT/LCD/: LCD.c
    ../LINK_OUT/HAL_24C02/: 24C02.c
    ../LINK_OUT/HAL_SDRAM/: HAL_SDRAM.c
    ../LINK_OUT/HAL_LTDC/: HAL_LTDC.c
    ../LINK_OUT/USART/: USART.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group LIB
    ../HAL_LIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc_ex.c
  group DW1000
    ../DWM1000_Con/: dwOps.c cfg.c libdw1000.c libdw1000Spi.c spi.c eeprom.c i2c.c
